# Keil uVision project Comparator_PSoC4_Example01_PSoC4lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C4245AXI-483 Cypress
  cpu: "IRAM(0x20000000-0x20000FFF)IROM(0x0-0x7FFF)CLOCK(48000000)CPUTYPE( "Cortex-M0") ESEL ELITTLE"
  output: Comparator_PSoC4_Example01_PSoC4lib (library)
  group Source Files
    ./Generated_Source/PSoC4/: cyfitter_cfg.h cyfitter_cfg.c cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h Comp.h Comp.c Comp_PM.c LED.c LED.h LED_aliases.h V1.c V1.h V1_aliases.h V2.c V2.h V2_aliases.h LCD.c LCD.h LCD_PM.c LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h cm0gcc.ld Cm0RealView.scat core_cm0_psoc4.h core_cm0.c core_cm0.h CyBootAsmGnu.s CyFlash.c CyFlash.h CyLib.c CyLib.h cyPm.c cyPm.h cytypes.h cyutils.c cypins.h project.h UART.c UART.h UART_SPI_UART.h UART_SPI_UART.c UART_SPI_UART_INT.c UART_PM.c UART_UART.c UART_BOOT.c UART_UART_BOOT.c UART_PINS.h UART_SPI_UART_PVT.h UART_PVT.h UART_rx.c UART_rx.h UART_rx_aliases.h UART_SCBCLK.c UART_SCBCLK.h UART_tx.c UART_tx.h UART_tx_aliases.h
target Release (ARM-GNU)
  device: CY8C4245AXI-483 Cypress
  cpu: as above
  output: Comparator_PSoC4_Example01_PSoC4lib (library)
